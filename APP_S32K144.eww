<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\APP_S32K144.ewp</path>
    </project>
    <batchBuild />
</workspace>
