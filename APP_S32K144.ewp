# IAR project APP_S32K144.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: S32K144 NXP S32K144
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CPU_S32K144HFT0VLLT; __ICCARM__; USING_OS_FREERTOS
  ICCARM.CCIncludePath2: Sources; Sources\HardwareLib; SDK; SDK\rtos; SDK\devices; SDK\devices\common; SDK\devices\S32K144\include; SDK\devices\S32K144\startup; SDK\drivers; SDK\drivers\inc; SDK\drivers\inc\phy; SDK\drivers\src; SDK\drivers\src\clock; SDK\drivers\src\clock\S32K1xx; SDK\drivers\src\flash; SDK\drivers\src\interrupt; SDK\drivers\src\power; SDK\drivers\src\power\S32K1xx; SDK\rtos; SDK\rtos\FreeRTOS_S32K\Source\include; SDK\rtos\FreeRTOS_S32K\Source\portable\IAR\ARM_CM4F; SDK\rtos\FreeRTOS_S32K\Source; SDK\rtos\osif; SDK\linker; Generated_Code; SDK\rtos\FreeRTOS_S32K\Source\include; SDK\platform\drivers\src\clock\S32K1xx; Sources\HardwareLib; SDK\rtos\FreeRTOS_S32K\Source\portable\MemMang; SDK\rtos
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: APP_S32K144.bin
  ILINK.IlinkOutputFile: APP_S32K144.out
  ILINK.IlinkIcfFile: D:\dengtongbei\IAR_works\APP_S32K144\SDK\linker\S32K144_64_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Generated_Code
    Generated_Code/: clockMan1.c clockMan1.h Cpu.c Cpu.h Flash1.c Flash1.h pin_mux.c pin_mux.h pwrMan1.c pwrMan1.h
  group SDK/devices
    SDK/devices/: callbacks.h devassert.h device_registers.h startup.c startup.h status.h
  group SDK/devices/common
    SDK/devices/common/: s32_core_cm4.h
  group SDK/devices/S32K144/include
    SDK/devices/S32K144/include/: S32K144.h S32K144_features.h
  group SDK/devices/S32K144/startup
    SDK/devices/S32K144/startup/: startup_S32K144.s system_S32K144.c system_S32K144.h
  group SDK/drivers/inc
    SDK/drivers/inc/: adc_driver.h clock.h clock_manager.h cmp_driver.h crc_driver.h csec_driver.h edma_driver.h eim_driver.h enet_driver.h erm_driver.h ewm_driver.h flash_driver.h flash_mx25l6433f_driver.h flexcan_driver.h flexio.h flexio_i2c_driver.h flexio_i2s_driver.h flexio_spi_driver.h flexio_uart_driver.h ftm_common.h ftm_ic_driver.h ftm_mc_driver.h ftm_oc_driver.h ftm_pwm_driver.h ftm_qd_driver.h interrupt_manager.h lin_driver.h lpi2c_driver.h lpit_driver.h lpspi_master_driver.h lpspi_shared_function.h lpspi_slave_driver.h lptmr_driver.h lpuart_driver.h mpu_driver.h pdb_driver.h pins_driver.h power_manager.h quadspi_driver.h rtc_driver.h sai_driver.h trgmux_driver.h wdog_driver.h
  group SDK/drivers/inc/phy
    SDK/drivers/inc/phy/: phy.h phy_generic.h phy_tja110x.h
  group SDK/drivers/src/clock/S32K1xx
    SDK/drivers/src/clock/S32K1xx/: clock_S32K1xx.c clock_S32K1xx.h pcc_hw_access.h pmc_hw_access.h scg_hw_access.h sim_hw_access.h smc_hw_access.h
  group SDK/drivers/src/flash
    SDK/drivers/src/flash/: flash_driver.c
  group SDK/drivers/src/interrupt
    SDK/drivers/src/interrupt/: interrupt_manager.c
  group SDK/drivers/src/pins
    SDK/drivers/src/pins/: pins_driver.c pins_gpio_hw_access.h pins_port_hw_access.c pins_port_hw_access.h
  group SDK/drivers/src/power
    SDK/drivers/src/power/: power_manager.c
  group SDK/drivers/src/power/S32K1xx
    SDK/drivers/src/power/S32K1xx/: power_manager_S32K1xx.c power_manager_S32K1xx.h power_rcm_hw_access.h power_scg_hw_access.h power_smc_hw_access.c power_smc_hw_access.h
  group SDK/linker
    SDK/linker/: S32K144_64_flash.icf S32K144_64_ram.icf
  group SDK/rtos
    SDK/rtos/: FreeRTOSConfig.h
  group SDK/rtos/FreeRTOS_S32K/Source
    SDK/rtos/FreeRTOS_S32K/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group SDK/rtos/FreeRTOS_S32K/Source/include
    SDK/rtos/FreeRTOS_S32K/Source/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group SDK/rtos/FreeRTOS_S32K/Source/portable/IAR/ARM_CM4F
    SDK/rtos/FreeRTOS_S32K/Source/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group SDK/rtos/FreeRTOS_S32K/Source/portable/MemMang
    SDK/rtos/FreeRTOS_S32K/Source/portable/MemMang/: heap_4.c
  group SDK/rtos/osif
    SDK/rtos/osif/: osif.h osif_freertos.c
  group Sources
    Sources/: main.c RTOS_Task.c RTOS_Task.h
  group Sources/HardwareLib
    Sources/HardwareLib/: FlashWriteRead.c FlashWriteRead.h GPIO_init.c GPIO_init.h HardwareLib.h latency.c latency.h LP_IT_timer.c LP_IT_timer.h LPTMR.c LPTMR.h LPUART.c LPUART.h OLED_FONT.c OLED_FONT.h PowerSwitch.c PowerSwitch.h RGB_LED.c RGB_LED.h SPI_OLED.c SPI_OLED.h Ymodem.c Ymodem.h
